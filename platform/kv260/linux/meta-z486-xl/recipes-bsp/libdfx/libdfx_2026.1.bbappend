# This generic rootfs machine is deployed only on KV260 in this project.
COMPATIBLE_MACHINE:amd-cortexa53-mali-common = "amd-cortexa53-mali-common"
